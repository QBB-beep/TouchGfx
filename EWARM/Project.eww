<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L4R9I_DISCOVERY.ewp</path>
  </project>
  <batchBuild />
</workspace>
